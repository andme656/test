# Keil uVision project anjian.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: anjian +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\USER\KEY;..\USER\LED;..\USER;..\Libraries;..\USER\USART;..\USER\SRAM;..\USER\LCD;..\USER\SYSTEM\delay;..\USER\SYSTEM\sys;..\USER\RTC;..\USER\ADC;..\USER\PID;..\USER\TIME;..\USER\EEPROM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/startup/arm/: startup_stm32f10x_hd.s
  group USER
    ../USER/: main.c stm32f10x_it.c
    ../USER/KEY/: key.c
    ../USER/LED/: led.c
    ../USER/USART/: usart.c
    ../USER/LCD/: bsp_lcd.c
    ../USER/SYSTEM/delay/: delay.c
    ../USER/SYSTEM/sys/: sys.c
    ../USER/RTC/: bsp_rtc.c
    ../USER/ADC/: adc.c
    ../USER/PID/: pid.c
    ../USER/TIME/: motor.c encoder.c
    ../USER/EEPROM/: bsp_ee_i2c.c bsp_i2c.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/: core_cm3.c system_stm32f10x.c
